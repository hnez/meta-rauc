include rauc-hawkbit-updater.inc

SRC_URI = "git://github.com/rauc/rauc-hawkbit-updater.git;protocol=https;branch=master"
SRCREV = "2d826bd355cb4f88db15eb37e8e70abd6e704c43"
PV = "1.4+git"

DEFAULT_PREFERENCE = "-1"
